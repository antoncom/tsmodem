## package/kernel/gpio-ch341/Config.in
```kconfig
menu "Configuration"
  config GPIO_CH341_ENABLE
    bool "Enable driver support GPIO for CH341"
    default n

endmenu
```
